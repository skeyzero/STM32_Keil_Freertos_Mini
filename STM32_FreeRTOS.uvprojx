# Keil uVision project STM32_FreeRTOS.uvprojx, settings and files
target Source (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group usr
    ./usr/: main.c
  group freertos
    ./FreeRTOS/: croutine.c timers.c list.c queue.c tasks.c heap_2.c port.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
